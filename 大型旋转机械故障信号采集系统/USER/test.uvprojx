# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\STM32F10x_DSP_Lib\inc;..\HARDWARE\DAC;..\HARDWARE\24CXX;..\HARDWARE\RS485;..\HARDWARE\IIC;..\STM32F10x_FWLib\inc;..\HARDWARE\MyFun;..\HARDWARE\MyFun2;..\HARDWARE\MyFun3;..\HARDWARE\MyFun4
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/STM32F10x_DSP_Lib/src/: cr4_fft_1024_stm32.s
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/MyFun/: MyFun.c MyFun_initialize.c MyFun_terminate.c
    ../HARDWARE/MyFun2/: rt_nonfinite.c rtGetInf.c rtGetNaN.c
    ../HARDWARE/MyFun4/: fft.c hilbert.c MyFun4.c MyFun4_data.c MyFun4_initialize.c MyFun4_terminate.c
  group README
    ../: README.TXT
